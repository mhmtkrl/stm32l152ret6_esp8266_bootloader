# Keil uVision project FOTA_ESP8266.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FOTA_ESP8266
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group MAIN
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.10.3
