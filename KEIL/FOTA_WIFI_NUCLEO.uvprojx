# Keil uVision project FOTA_WIFI_NUCLEO.uvprojx, settings and files
target Layers (6160000::V6.16::ARMCLANG)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FOTA_WIFI_NUCLEO +hex
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe --bin Objects\FOTA_WIFI_NUCLEO.axf --output Code.bin
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PRE_INCLUDE_GLOBAL_H
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --no_autoat
  group Source Group 1
    ./: main.c
  group GPIO
    ./: Gpio.c Gpio.h
  group SYSTEM_TIMER
    ./: Sys_Timer.c Sys_Timer.h Sys_Timer_Api.h
  group UART
    ./: Uart.c Uart.h Uart_Comm.c Uart_Comm.h Uart_Api.h
  group ESP8266
    ./: Esp8266_Config.c Esp8266_Config.h Esp8266.c Esp8266.h Esp8266_Api.h ESP8266_Enums.h
  group CRC
    ./: CRC_Calculation.c CRC_Calculation.h CRC_Calculation_Api.h
  group MY_PROTOCOL
    ./: My_Protocol.c My_Protocol.h My_Protocol_Api.h
  group FLASH
    ./: Flash_Unit.c Flash_Unit.h Flash_Unit_Api.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.10.3
